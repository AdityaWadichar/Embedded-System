BACK: MOV P0, #11110111B ; CHECKING FOR FOURTH ROW 

JNB P0.6, ONE
JNB P0.5, TWO
JNB P0.4, THREE

MOV P0, #11111011B ; CHECKING FOR THIRD ROW
JNB P0.6, FOUR
JNB P0.5, FIVE
JNB P0.4, SIX

MOV P0, #11111101B ; CHECKING FOR SECOND ROW
JNB P0.6, SEVEN
JNB P0.5, EIGHT
JNB P0.4, NINE

MOV P0, #11111110B ; CHECKING FOR FIRST ROW
JNB P0.5, ZERO
MOV A, #00H ; IF NO BUTTON IS PRESSED, ALL LEDS ARE ON
JMP HERE

ZERO: MOV A, #0FFH
JMP HERE
ONE: MOV A, #0FEH
JMP HERE
TWO: MOV A, #0FDH
JMP HERE
THREE: MOV A, #0FCH
JMP HERE
FOUR: MOV A, #0FBH
JMP HERE
FIVE: MOV A, #0FAH
JMP HERE
SIX: MOV A, #0F9H
JMP HERE
SEVEN: MOV A, #0F8H
JMP HERE
EIGHT: MOV A, #0F7H
JMP HERE
NINE: MOV A, #0F6H

HERE: MOV P1, A
JMP BACK
